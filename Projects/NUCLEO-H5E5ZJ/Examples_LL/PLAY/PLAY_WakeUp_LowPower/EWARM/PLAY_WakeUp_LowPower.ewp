# IAR project PLAY_WakeUp_LowPower.ewp, settings and files
configuration PLAY_WakeUp_LowPower (ARM, debug)
  General.OGChipSelectEditMenu: STM32H5E5ZJ ST STM32H5E5ZJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32H5E5xx; HSE_VALUE=48000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=64000000; LSI_VALUE=32000; VDD_VALUE=3300
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32H5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PLAY_WakeUp_LowPower.hex
  ILINK.IlinkOutputFile: PLAY_WakeUp_LowPower.out
  ILINK.IlinkIcfFile: stm32h5e5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h5e5xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_ll_utils.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_icache.c stm32h5xx_ll_rcc.c stm32h5xx_ll_play.c stm32h5xx_ll_pwr.c
