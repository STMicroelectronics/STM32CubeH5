<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PLAY_WakeUp_LowPower.ewp</path>
  </project>
  <batchBuild />
</workspace>
