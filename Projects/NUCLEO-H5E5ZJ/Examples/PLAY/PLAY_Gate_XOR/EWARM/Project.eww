<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PLAY_Gate_XOR.ewp</path>
  </project>
  <batchBuild />
</workspace>
