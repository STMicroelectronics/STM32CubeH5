<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PLAY_Counter_3bits.ewp</path>
  </project>
  <batchBuild />
</workspace>
