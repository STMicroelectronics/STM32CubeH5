<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PLAY_Emergency_Alarm.ewp</path>
  </project>
  <batchBuild />
</workspace>
