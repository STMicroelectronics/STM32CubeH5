# IAR project CORDIC_Phase.ewp, settings and files
configuration CORDIC_Phase (ARM, debug)
  General.OGChipSelectEditMenu: STM32H5E5ZJ ST STM32H5E5ZJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H5E5xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../Drivers/CMSIS/DSP/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CORDIC_Phase.hex
  ILINK.IlinkOutputFile: CORDIC_Phase.out
  ILINK.IlinkIcfFile: stm32h5e5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h5e5xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_exti.c stm32h5xx_hal_cordic.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_icache.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/DSP/Source/SupportFunctions/: arm_float_to_q31.c arm_q31_to_float.c
    ../Src/: system_stm32h5xx.c
