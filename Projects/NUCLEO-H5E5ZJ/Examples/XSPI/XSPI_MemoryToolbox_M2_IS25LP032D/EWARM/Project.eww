<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\XSPI_MemoryToolbox_M2_IS25LP032D.ewp</path>
  </project>
  <batchBuild />
</workspace>
