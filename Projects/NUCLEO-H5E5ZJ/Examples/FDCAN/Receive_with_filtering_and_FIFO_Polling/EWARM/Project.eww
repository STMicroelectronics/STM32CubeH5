<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Receive_with_filtering_and_FIFO_Polling.ewp</path>
  </project>
  <batchBuild />
</workspace>
