<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Receive with filtering and FIFO_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>
