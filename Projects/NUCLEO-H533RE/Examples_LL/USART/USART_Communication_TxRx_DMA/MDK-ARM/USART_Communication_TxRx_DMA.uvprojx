# Keil uVision project USART_Communication_TxRx_DMA.uvprojx, settings and files
target USART_Communication_TxRx_DMA (6190000::V6.19::ARMCLANG)
  device: STM32H533RETx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20043FFF) IROM(0x08000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: USART_Communication_TxRx_DMA +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,ART_ACCELERATOR_ENABLE=0,STM32H533xx
  c include: ../Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x44000
  group Application/MDK-ARM
    ./: startup_stm32h533xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c
  group Doc
    ../: README.md
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_ll_utils.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_dma.c stm32h5xx_ll_rcc.c stm32h5xx_ll_icache.c stm32h5xx_ll_pwr.c stm32h5xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
software components: CMSIS:CORE 4.3.0
