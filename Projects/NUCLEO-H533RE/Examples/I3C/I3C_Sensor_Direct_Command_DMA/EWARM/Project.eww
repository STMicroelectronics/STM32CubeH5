<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I3C_Sensor_Direct_Command_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
