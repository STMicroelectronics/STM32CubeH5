<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HASH_HMAC_SHA2_384.ewp</path>
  </project>
  <batchBuild />
</workspace>
