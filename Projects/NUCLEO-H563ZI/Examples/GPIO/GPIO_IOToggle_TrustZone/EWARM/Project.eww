<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NonSecure\GPIO_IOToggle_TrustZone_NS.ewp</path>
  </project><project>
    <path>$WS_DIR$\Secure\GPIO_IOToggle_TrustZone_S.ewp</path>
  </project>
  <batchBuild />
</workspace>
