# IAR project RTC_TrustZone_NS.ewp, settings and files
configuration RTC_TrustZone_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx
  ICCARM.CCIncludePath2: ../../NonSecure/Inc; ../../Secure_nsclib; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTC_TrustZone_NS.hex
  ILINK.IlinkOutputFile: RTC_TrustZone_NS.out
  ILINK.IlinkIcfFile: stm32h563xx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32h5xx_ns.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c
