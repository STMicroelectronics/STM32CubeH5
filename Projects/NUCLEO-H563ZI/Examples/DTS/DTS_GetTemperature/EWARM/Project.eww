<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DTS_GetTemperature.ewp</path>
  </project>
  <batchBuild />
</workspace>
