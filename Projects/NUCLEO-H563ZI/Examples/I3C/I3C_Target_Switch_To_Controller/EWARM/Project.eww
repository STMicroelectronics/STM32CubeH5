<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I3C_Target_Switch_To_Controller.ewp</path>
  </project>
  <batchBuild />
</workspace>
