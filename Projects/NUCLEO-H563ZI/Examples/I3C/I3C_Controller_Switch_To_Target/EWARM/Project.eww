<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I3C_Controller_Switch_To_Target.ewp</path>
  </project>
  <batchBuild />
</workspace>
