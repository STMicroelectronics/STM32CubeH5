# IAR project PKA_ECDSA_Verify.ewp, settings and files
configuration PKA_ECDSA_Verify (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32H5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PKA_ECDSA_Verify.hex
  ILINK.IlinkOutputFile: PKA_ECDSA_Verify.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User
    ../Src/: prime256v1.c SigVer.c main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_exti.c stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_pka.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
