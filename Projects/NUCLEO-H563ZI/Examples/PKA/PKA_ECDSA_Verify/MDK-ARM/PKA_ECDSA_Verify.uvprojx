# Keil uVision project PKA_ECDSA_Verify.uvprojx, settings and files
target PKA_ECDSA_Verify (6180000::V6.18::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.3.1
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2009FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: PKA_ECDSA_Verify +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ../Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32H5xx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User
    ../Src/: prime256v1.c SigVer.c main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_exti.c stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_pka.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
