# IAR project Project_s.ewp, settings and files
configuration NUCLEO-H563ZI_OEMiROT_Appli_TrustZone_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32H563xx; USE_HAL_DRIVER; BL2
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include; ..\..\..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc; ..\..\Secure\Inc; ..\..\Secure_nsclib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\Binary\rot_tz_s_app.bin
  postbuild: ..\postbuild.bat "secure"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h563xx_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Secure/Src/: low_level_device.c low_level_flash.c main.c secure_nsc.c stm32h5xx_it.c
    ../: startup_stm32h563xx.s
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32h5xx_s.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c
