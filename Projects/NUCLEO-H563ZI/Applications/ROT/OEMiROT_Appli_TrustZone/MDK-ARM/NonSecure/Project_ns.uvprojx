# Keil uVision project Project_ns.uvprojx, settings and files
target NUCLEO-H563ZI_OEMiROT_Appli_TrustZone_NS (6180000::V6.18::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.0.0
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\..\Binary\rot_tz_ns_app.bin"
  AfterMake: ..\postbuild.bat "nonsecure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H563xx,USE_HAL_DRIVER,BL2
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../NonSecure/Inc;../../Secure_nsclib
  library: MicroLIB
  scatter file: stm32h563xx_ns.sct
  link misc: ../Secure/veneer.o
  group Doc
    ../../: README.md
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32h5xx_ns.c
  group Application/User
    ../../NonSecure/Src/: low_level_flash.c low_level_device.c com.c common.c stm32h5xx_it.c main.c
    ../: startup_stm32h563xx.s
