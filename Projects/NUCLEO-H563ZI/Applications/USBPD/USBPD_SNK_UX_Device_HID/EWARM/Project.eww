<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USBPD_SNK_UX_Device_HID.ewp</path>
  </project>
  <batchBuild />
</workspace>
