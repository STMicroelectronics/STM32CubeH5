# Keil uVision project Project.uvprojx, settings and files
target Templates_OEMiROT_Appli (6180000::V6.18::ARMCLANG)
  device: STM32H503RBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.0.0
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\rot_app.bin"
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H503xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H5xx_Nucleo
  library: MicroLIB
  scatter file: stm32h5xx_app.sct
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_comp.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dac.c stm32h5xx_hal_dac_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_dts.c stm32h5xx_hal_exti.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_hash.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_i2s.c stm32h5xx_hal_i2s_ex.c stm32h5xx_hal_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_irda.c stm32h5xx_hal_iwdg.c stm32h5xx_hal_lptim.c stm32h5xx_hal_opamp.c stm32h5xx_hal_opamp_ex.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_ramcfg.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_smartcard.c stm32h5xx_hal_smartcard_ex.c stm32h5xx_hal_smbus.c stm32h5xx_hal_smbus_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_wwdg.c
  group Example/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
software components: CMSIS:CORE 4.3.0
