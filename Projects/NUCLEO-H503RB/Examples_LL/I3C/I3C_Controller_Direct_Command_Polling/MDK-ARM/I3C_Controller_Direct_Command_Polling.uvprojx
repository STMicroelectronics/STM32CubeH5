# Keil uVision project I3C_Controller_Direct_Command_Polling.uvprojx, settings and files
target I3C_Controller_Direct_Command_Polling (6190000::V6.19::ARMCLANG)
  device: STM32H503RBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: I3C_Controller_Direct_Command_Polling +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,ART_ACCELERATOR_ENABLE=0,STM32H503xx,__DBG_ITM
  c include: ../Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c
    ./: Serial.c Retarget.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_ll_utils.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_i3c.c stm32h5xx_ll_dma.c stm32h5xx_ll_rcc.c stm32h5xx_ll_icache.c stm32h5xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Doc
    ../: README.md
software components: CMSIS:CORE 4.3.0
