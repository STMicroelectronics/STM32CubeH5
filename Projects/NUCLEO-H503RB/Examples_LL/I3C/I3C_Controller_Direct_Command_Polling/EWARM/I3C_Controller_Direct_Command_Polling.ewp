# IAR project I3C_Controller_Direct_Command_Polling.ewp, settings and files
configuration I3C_Controller_Direct_Command_Polling (ARM, debug)
  General.OGChipSelectEditMenu: STM32H503RB ST STM32H503RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=25000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=64000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=0; ART_ACCELERATOR_ENABLE=0; STM32H503xx; HSE_VALUE=24000000
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I3C_Controller_Direct_Command_Polling.hex
  ILINK.IlinkOutputFile: I3C_Controller_Direct_Command_Polling.out
  ILINK.IlinkIcfFile: stm32h503xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h503xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_ll_utils.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_i3c.c stm32h5xx_ll_dma.c stm32h5xx_ll_rcc.c stm32h5xx_ll_icache.c stm32h5xx_ll_pwr.c
