<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I3C_Target_WakeUpFromStop.ewp</path>
  </project>
  <batchBuild />
</workspace>
