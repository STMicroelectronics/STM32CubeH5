<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I3C_Controller_I2C_ComDMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
