# Keil uVision project Templates_Board.uvprojx, settings and files
target Templates_Board (6190000::V6.19::ARMCLANG)
  device: STM32H553ZGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x20000000-0x2004CFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Templates_Board +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_NUCLEO_144,USE_HAL_DRIVER,STM32H553xx
  c include: ../Inc;../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../Drivers/BSP/STM32H5xx_Nucleo;../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x4c000
  group Application/MDK-ARM
    ./: startup_stm32h553xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
software components: CMSIS:CORE 4.3.0
