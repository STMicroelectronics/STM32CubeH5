# Keil uVision project TrustZoneEnabled_NoIsolation.uvprojx, settings and files
target TrustZoneEnabled_NoIsolation (6210000::V6.21::ARMCLANG)
  device: STM32H553ZGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x30000000-0x3004FFFF) IROM(0x0C000000-0xC0FDFFF) IROM2(0x0C0FE000-0xC0FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: TrustZoneEnabled_NoIsolation +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H553xx,USE_HAL_DRIVER
  c include: ..\Inc;..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\Drivers\BSP\STM32H5xx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT5: ROM 0xc0fe000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x120000
  link misc: --diag_suppress L6314E --diag_suppress L6848E
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx_s.c
  group Example/MDK-ARM
    ./: startup_stm32h553xx.s
  group Example/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_icache.c stm32h5xx_hal_cortex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_exti.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
software components: CMSIS:CORE 5.6.0
