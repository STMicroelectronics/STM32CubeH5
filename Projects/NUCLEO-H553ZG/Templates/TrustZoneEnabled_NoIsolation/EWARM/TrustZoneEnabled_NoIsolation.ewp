# IAR project TrustZoneEnabled_NoIsolation.ewp, settings and files
configuration TrustZoneEnabled_NoIsolation_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32H553ZG ST STM32H553ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H553xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/STM32H5xx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrustZoneEnabled_NoIsolation.hex
  ILINK.IlinkOutputFile: TrustZoneEnabled_NoIsolation.out
  ILINK.IlinkIcfFile: stm32h553xx_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h553xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/CMSIS
    ../Src/: system_stm32h5xx_s.c
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
