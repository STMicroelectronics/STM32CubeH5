# Keil uVision project TrustZoneDisabled.uvprojx, settings and files
target TrustZoneDisabled (6190000::V6.19::ARMCLANG)
  device: STM32H553ZGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x20000000-0x2017FFFF) IROM(0x08000000-0x83FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: TrustZoneDisabled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=48000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,STM32H553xx
  c include: ../Inc;../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x4c000
  group Application/MDK-ARM
    ./: startup_stm32h553xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_ll_adc.c stm32h5xx_ll_comp.c stm32h5xx_ll_cordic.c stm32h5xx_ll_crc.c stm32h5xx_ll_crs.c stm32h5xx_ll_dac.c stm32h5xx_ll_dma.c stm32h5xx_ll_dma2d.c stm32h5xx_ll_exti.c stm32h5xx_ll_fmac.c stm32h5xx_ll_gpio.c stm32h5xx_ll_i2c.c stm32h5xx_ll_i3c.c stm32h5xx_ll_icache.c stm32h5xx_ll_lptim.c stm32h5xx_ll_lpuart.c stm32h5xx_ll_opamp.c stm32h5xx_ll_pka.c stm32h5xx_ll_pwr.c stm32h5xx_ll_play.c stm32h5xx_ll_rcc.c stm32h5xx_ll_rng.c stm32h5xx_ll_rtc.c stm32h5xx_ll_spi.c stm32h5xx_ll_tim.c stm32h5xx_ll_ucpd.c stm32h5xx_ll_usart.c stm32h5xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
software components: CMSIS:CORE 4.3.0
