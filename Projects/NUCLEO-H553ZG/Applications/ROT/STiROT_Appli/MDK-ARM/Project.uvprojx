# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-H553ZG_STiROT_Appli (6190000::V6.19::ARMCLANG)
  device: STM32H553ZGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\appli.bin"
  AfterMake: postbuild.bat "secure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H553xx,USE_HAL_DRIVER,USE_NUCLEO_H553ZG
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc
  library: MicroLIB
  scatter file: stm32h5xx_app.sct
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c
  group Example/MDK-ARM
    ./: startup_stm32h553xx.s
  group Application/User
    ../Src/: com.c stm32h5xx_it.c low_level_security.c main.c loader.c test_versions.c low_level_obkeys.c
software components: CMSIS:CORE 5.6.0
