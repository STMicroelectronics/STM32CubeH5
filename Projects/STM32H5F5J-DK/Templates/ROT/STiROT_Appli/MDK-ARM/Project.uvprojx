# Keil uVision project Project.uvprojx, settings and files
target Templates_STiROT_Appli (6190000::V6.19::ARMCLANG)
  device: STM32H5F5LJHxQ STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x20060000,0x00120000) IROM(0x08000000,0x00400000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\appli.bin"
  AfterMake: postbuild.bat "secure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H5F5xx,USE_HAL_DRIVER,USE_STM32H5F5J_DK
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H5F5J-DK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x120000
  scatter file: stm32h5xx_app.sct
  group Doc
    ../: README.md
  group BSP/STM32H5F5J-DK
    ../../../../../../Drivers/BSP/STM32H5F5J-DK/: stm32h5f5j_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_cec.c stm32h5xx_hal_cordic.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_dac.c stm32h5xx_hal_dac_ex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_dcmi.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_dts.c stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_fmac.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_hash.c stm32h5xx_hal_hcd.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_i2s.c stm32h5xx_hal_i2s_ex.c stm32h5xx_hal_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_irda.c stm32h5xx_hal_iwdg.c stm32h5xx_hal_lptim.c stm32h5xx_hal_mmc.c stm32h5xx_hal_mmc_ex.c stm32h5xx_hal_nand.c stm32h5xx_hal_nor.c stm32h5xx_hal_otfdec.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pka.c stm32h5xx_hal_pssi.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_ramcfg.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_sai.c stm32h5xx_hal_sai_ex.c stm32h5xx_hal_sd.c stm32h5xx_hal_sd_ex.c stm32h5xx_hal_sdram.c stm32h5xx_hal_smartcard.c stm32h5xx_hal_smartcard_ex.c stm32h5xx_hal_smbus.c stm32h5xx_hal_smbus_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_sram.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_wwdg.c stm32h5xx_hal_xspi.c stm32h5xx_ll_adc.c stm32h5xx_ll_dlyb.c stm32h5xx_ll_fmc.c stm32h5xx_ll_sdmmc.c stm32h5xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32h5f5xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
software components: CMSIS:CORE 4.3.0
