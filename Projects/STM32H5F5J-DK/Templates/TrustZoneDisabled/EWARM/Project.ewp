# IAR project Project.ewp, settings and files
configuration Templates_TrustZoneDisabled (ARM, debug)
  General.OGChipSelectEditMenu: STM32H5F5LJ ST STM32H5F5LJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32H5F5xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../Drivers/BSP/STM32H5F5J-DK; ../../../../../Drivers/BSP/Components/st1633i; ../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h5f5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5F5J-DK
    ../../../../../Drivers/BSP/STM32H5F5J-DK/: stm32h5f5j_discovery.c stm32h5f5j_discovery_bus.c stm32h5f5j_discovery_lcd.c stm32h5f5j_discovery_ts.c stm32h5f5j_discovery_xspi.c stm32h5f5j_discovery_motion_sensors.c stm32h5f5j_discovery_motion_sensors_ex.c stm32h5f5j_discovery_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/Components
    ../../../../../Drivers/BSP/Components/aps6408/: aps6408.c
    ../../../../../Drivers/BSP/Components/lan8742/: lan8742.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../Drivers/BSP/Components/st1633i/: st1633i.c
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_ccb.c stm32h5xx_hal_cec.c stm32h5xx_hal_comp.c stm32h5xx_hal_cordic.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_dac.c stm32h5xx_hal_dac_ex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_dcmi.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma2d.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_dts.c stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_fmac.c stm32h5xx_hal_gfxtim.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_hash.c stm32h5xx_hal_hcd.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_i2s.c stm32h5xx_hal_i2s_ex.c stm32h5xx_hal_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_irda.c stm32h5xx_hal_iwdg.c stm32h5xx_hal_jpeg.c stm32h5xx_hal_lptim.c stm32h5xx_hal_ltdc.c stm32h5xx_hal_ltdc_ex.c stm32h5xx_hal_mdf.c stm32h5xx_hal_mmc.c stm32h5xx_hal_mmc_ex.c stm32h5xx_hal_nand.c stm32h5xx_hal_nor.c stm32h5xx_hal_opamp.c stm32h5xx_hal_opamp_ex.c stm32h5xx_hal_otfdec.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pka.c stm32h5xx_hal_play.c stm32h5xx_hal_pssi.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_ramcfg.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_sai.c stm32h5xx_hal_sai_ex.c stm32h5xx_hal_sd.c stm32h5xx_hal_sd_ex.c stm32h5xx_hal_sdio.c stm32h5xx_hal_sdram.c stm32h5xx_hal_smartcard.c stm32h5xx_hal_smartcard_ex.c stm32h5xx_hal_smbus.c stm32h5xx_hal_smbus_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_sram.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_wwdg.c stm32h5xx_hal_xspi.c stm32h5xx_ll_dlyb.c stm32h5xx_ll_fmc.c stm32h5xx_ll_sdmmc.c stm32h5xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32h5f5xx.s
  group Example/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
