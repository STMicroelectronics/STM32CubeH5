# Keil uVision project Project.uvprojx, settings and files
target TrustZoneDisabled_RSA_PKCS1v2.2_EncryptDecryptCRT_HAL (6210000::V6.21::ARMCLANG)
  device: STM32H5F5LJHxQ STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x20000000-0x0005FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) DSP CPUTYPE("Cortex-M33") ELITTLE TZ
  output: TrustZoneDisabled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H5F5xx,USE_HAL_DRIVER,USE_FULL_ASSERT,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,MBEDTLS_USER_CONFIG_FILE=<mbedtls_alt_config.h>,USE_HAL_HASH_SUSPEND_RESUME=1
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H5F5J-DK;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls;../../../../../../Middlewares/Third_Party/mbed-crypto/include/psa;../../../../../../Middlewares/Third_Party/mbed-crypto/library;../../../../../../Drivers/BSP/STM32H5F5J-DK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x5ffff
  memory RVCT10: RAM 0x20060000 size 0x120000
  group Application/User
    ../Src/: stm32h5xx_it.c stm32h5xx_hal_msp.c main.c
  group Doc
    ../: README.md
  group Middlewares/ST/mbedtls_alt
    ../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns/: entropy_hardware_alt.c aes_alt.c rsa_alt.c sha256_alt.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: psa_crypto_hash.c psa_crypto_rsa.c aes.c psa_crypto.c psa_crypto_cipher.c psa_crypto_mac.c psa_crypto_client.c psa_crypto_slot_management.c psa_crypto_driver_wrappers_no_static.c psa_util.c asn1parse.c asn1write.c pkparse.c pk.c pk_wrap.c pkwrite.c rsa.c rsa_alt_helpers.c bignum.c bignum_core.c oid.c md.c platform_util.c sha256.c cipher.c cipher_wrap.c ctr_drbg.c entropy.c platform.c constant_time.c psa_crypto_random.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_pka.c stm32h5xx_hal_hash.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_icache.c
  group Drivers/BSP/STM32H5F5J-DK
    ../../../../../../Drivers/BSP/STM32H5F5J-DK/: stm32h5f5j_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Example/MDK-ARM
    ./: startup_stm32h5f5xx.s
software components: CMSIS:CORE 4.3.0
