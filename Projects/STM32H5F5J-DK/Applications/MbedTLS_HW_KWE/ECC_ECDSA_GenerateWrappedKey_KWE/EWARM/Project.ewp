# IAR project Project.ewp, settings and files
configuration STM32H5F5J-DK_ECC_ECDSA_GenerateWrappedKey_KWE (ARM, debug)
  General.OGChipSelectEditMenu: STM32H5F5LJ ST STM32H5F5LJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32H5F5xx; USE_HAL_DRIVER; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; MBEDTLS_USER_CONFIG_FILE=<mbedtls_alt_config.h>
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include; ..\..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H5F5J-DK; ..\..\..\..\..\..\Middlewares\ST\mbedtls_alt\interfaces\patterns; ..\..\..\..\..\..\Middlewares\ST\mbedtls_key_wrap_engine\core; ..\..\..\..\..\..\Middlewares\ST\mbedtls_key_wrap_engine\interface; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\mbedtls; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\include\psa; ..\..\..\..\..\..\Middlewares\Third_Party\mbed-crypto\library; ..\..\..\..\..\..\Drivers\BSP\STM32H5F5J-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: TrustZoneDisabled.out
  ILINK.IlinkIcfFile: stm32h5f5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c storage_interface.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5F5J-DK
    ../../../../../../Drivers/BSP/STM32H5F5J-DK/: stm32h5f5j_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_ccb.c stm32h5xx_hal_cortex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pka.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c
  group Example/EWARM
    ./: startup_stm32h5f5xx.s
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c asn1parse.c asn1write.c bignum.c bignum_core.c constant_time.c ctr_drbg.c ecdsa.c ecp.c ecp_curves.c entropy.c hmac_drbg.c md.c platform.c platform_util.c psa_crypto.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c sha256.c psa_crypto_random.c
  group Middlewares/ST/mbedtls_alt
    ../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns/: aes_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c entropy_hardware_alt.c psa_its_alt.c
  group Middlewares/ST/mbedtls_key_wrap_engine
    ../../../../../../Middlewares/ST/mbedtls_key_wrap_engine/core/: kwe_core.c
    ../../../../../../Middlewares/ST/mbedtls_key_wrap_engine/interface/: kwe_psa_driver_interface.c kwe_psa_driver_key_management.c
