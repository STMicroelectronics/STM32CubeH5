# Keil uVision project Project.uvprojx, settings and files
target STM32H5F5J-DK_OEMiROT_Boot (6190000::V6.19::ARMCLANG)
  device: STM32H5F5LJHxQ STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x20060000,0x00120000) IROM(0x08000000,0x00400000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project
  BeforeMake: $J\..\bin\armclang --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -DSTM32H5F5xx -DBL2 -I..\..\Linker -I..\Inc -I..\..\..\..\..\..\Drivers\CMSIS\Include -I..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include -I..\..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc  ..\Src\image_macros_to_preprocess_bl2.c -o image_macros_preprocessed_bl2.c
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\OEMiROT_Boot.bin"
  AfterMake: postbuild.bat
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H5F5xx,USE_HAL_DRIVER,NDEBUG,MCUBOOT_TARGET_CONFIG=<flash_layout.h>,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,MCUBOOT_DOUBLE_SIGN_VERIF,FLOW_CONTROL,BL2,DEFAULT_UART_BAUDRATE=115200,OEMIROT_DEV_MODE,BOOT_MAX_ALIGN=16
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/include/psa;../../../../../../Middlewares/Third_Party/mcuboot;../../../../../../Middlewares/Third_Party/mcuboot/platform/include;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver;../../../../../../Middlewares/Third_Party/mcuboot/bl2/include;../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot;../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/include;../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/include;../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src;../../../../../../Middlewares/Third_Party/mcuboot/ext/tinycrypt/lib/include;..\..\OEMiROT_Boot;..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\hal\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x120000
  scatter file: .\stm32h5xx_bl2.sct
  link misc: --predefine=-I../Inc/
--predefine=-DBL2
  group Doc
    ../: README.md
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_ramcfg.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_pka.c stm32h5xx_hal_hash.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c image_ec.c image_ec256.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c asn1parse.c bignum.c bignum_core.c cipher.c hmac_drbg.c ecdh.c ecdsa.c ecp.c ecp_curves.c hkdf.c md.c memory_buffer_alloc.c platform.c platform_util.c sha256.c entropy.c cipher_wrap.c asn1write.c constant_time.c
  group Application/User
    ../Src/: low_level_flash.c low_level_com.c low_level_rng.c low_level_security.c tick.c boot_hal.c low_level_device.c stm32h5xx_hal_msp.c keys_map.c mpu_armv8m_drv.c sha256_alt.c bl2_nv_services.c low_level_obkeys.c low_level_obkeys_device.c startup_stm32h5xx.c
software components: CMSIS:CORE 5.6.0
