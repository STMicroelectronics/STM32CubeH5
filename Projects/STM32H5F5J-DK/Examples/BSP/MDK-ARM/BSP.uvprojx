# Keil uVision project BSP.uvprojx, settings and files
target BSP (6190000::V6.19::ARMCLANG)
  device: STM32H5F5LJHxQ STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x20000000-0x2017FFFF) IROM(0x08000000-0x83FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: BSP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H5F5xx
  c include: ../Inc;../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/STM32H5F5J-DK;../../../../../Utilities/lcd;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/mx25lm51245g;../../../../../Drivers/BSP/Components/st1633i
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x180000
  group Application/MDK-ARM
    ./: startup_stm32h5f5xx.s
  group Application/User
    ../Src/: lcd.c led.c xspi.c resources.c sd.c ts.c main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5F5J-DK
    ../../../../../Drivers/BSP/STM32H5F5J-DK/: stm32h5f5j_discovery.c stm32h5f5j_discovery_lcd.c stm32h5f5j_discovery_bus.c stm32h5f5j_discovery_sd.c stm32h5f5j_discovery_ts.c stm32h5f5j_discovery_xspi.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st1633i/: st1633i.c st1633i_reg.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../Drivers/BSP/Components/aps6408/: aps6408.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_exti.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma2d.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_ltdc.c stm32h5xx_hal_ltdc_ex.c stm32h5xx_hal_xspi.c stm32h5xx_ll_dlyb.c stm32h5xx_ll_sdmmc.c stm32h5xx_hal_sd.c stm32h5xx_hal_sd_ex.c stm32h5xx_hal_mmc.c stm32h5xx_hal_mmc_ex.c stm32h5xx_hal_sdio.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
software components: CMSIS:CORE 4.3.0
