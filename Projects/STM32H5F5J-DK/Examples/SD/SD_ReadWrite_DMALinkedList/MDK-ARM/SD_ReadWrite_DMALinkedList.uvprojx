# Keil uVision project SD_ReadWrite_DMALinkedList.uvprojx, settings and files
target SD_ReadWrite_DMALinkedList (6140001::V6.14.1::ARMCLANG)
  device: STM32H5F5LJHxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2017FFFF) IROM(0x08000000-0x83FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: SD_ReadWrite_DMALinkedList +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H5F5xx
  c include: ../Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32H5F5J-DK
  group Application/MDK-ARM
    ./: startup_stm32h5f5xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5F5J-DK
    ../../../../../../Drivers/BSP/STM32H5F5J-DK/: stm32h5f5j_discovery.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_exti.c stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_ll_sdmmc.c stm32h5xx_ll_dlyb.c stm32h5xx_hal_sd.c stm32h5xx_hal_sd_ex.c stm32h5xx_hal_mmc.c stm32h5xx_hal_mmc_ex.c stm32h5xx_hal_sdio.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
software components: CMSIS:CORE 4.3.0
