<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DMA2D_MemToMemWithPFC.ewp</path>
  </project>
  <batchBuild />
</workspace>
