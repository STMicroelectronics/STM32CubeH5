<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CCB_Protected_ECDSA_PublicKeyComputation.ewp</path>
  </project>
  <batchBuild />
</workspace>
