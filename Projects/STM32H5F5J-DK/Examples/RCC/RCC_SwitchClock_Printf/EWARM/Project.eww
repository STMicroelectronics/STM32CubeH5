<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RCC_SwitchClock_Printf.ewp</path>
  </project>
  <batchBuild />
</workspace>
