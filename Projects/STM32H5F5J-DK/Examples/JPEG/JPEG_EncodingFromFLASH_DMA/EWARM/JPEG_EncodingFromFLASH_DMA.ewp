# IAR project JPEG_EncodingFromFLASH_DMA.ewp, settings and files
configuration JPEG_EncodingFromFLASH_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32H5F5LJ ST STM32H5F5LJ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H5F5xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32H5F5J-DK; ../../../../../../Utilities/JPEG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: JPEG_EncodingFromFLASH_DMA.hex
  ILINK.IlinkOutputFile: JPEG_EncodingFromFLASH_DMA.out
  ILINK.IlinkIcfFile: stm32h5f5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h5f5xx.s
  group Application/User
    ../Src/: encode_dma.c Image_argb_8888.c Image_rgb_565.c Image_rgb_888.c main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5F5J-DK
    ../../../../../../Drivers/BSP/STM32H5F5J-DK/: stm32h5f5j_discovery.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_exti.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_icache.c stm32h5xx_hal_jpeg.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Utilities
    ../../../../../../Utilities/JPEG/: jpeg_utils.c
