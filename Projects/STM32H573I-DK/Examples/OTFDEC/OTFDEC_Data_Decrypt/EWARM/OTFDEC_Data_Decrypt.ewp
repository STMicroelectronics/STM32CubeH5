# IAR project OTFDEC_Data_Decrypt.ewp, settings and files
configuration OTFDEC_Data_Decrypt (ARM, debug)
  General.OGChipSelectEditMenu: STM32H573II ST STM32H573II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H573xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32H573I-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTFDEC_Data_Decrypt.hex
  ILINK.IlinkOutputFile: OTFDEC_Data_Decrypt.out
  ILINK.IlinkIcfFile: stm32h573xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h573xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H573I-DK
    ../../../../../../Drivers/BSP/STM32H573I-DK/: stm32h573i_discovery.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_exti.c stm32h5xx_hal_cryp.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_dcache.c stm32h5xx_hal_icache.c stm32h5xx_hal_xspi.c stm32h5xx_ll_dlyb.c stm32h5xx_hal_otfdec.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
