# Keil uVision project CEC_DataExchange_Device_1.uvprojx, settings and files
target CEC_DataExchange_Device_1 (6180000::V6.18::ARMCLANG)
  device: STM32H573IIKx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.0.0.5
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: CEC_DataExchange_Device_1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H573xx
  c include: ../Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32H573I-DK;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/lcd
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h573xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2_reg.c st7789h2.c
    ../../../../../../Drivers/BSP/Components/ft6x06/: ft6x06_reg.c ft6x06.c
  group Drivers/BSP/STM32H573I-DK
    ../../../../../../Drivers/BSP/STM32H573I-DK/: stm32h573i_discovery_ts.c stm32h573i_discovery_bus.c stm32h573i_discovery_lcd.c stm32h573i_discovery.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_ll_fmc.c stm32h5xx_hal_i2c.c stm32h5xx_hal_sram.c stm32h5xx_hal_exti.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal_cec.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_icache.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
software components: CMSIS:CORE 4.3.0
