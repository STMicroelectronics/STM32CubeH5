# IAR project GTZC_MPCWM_IllegalAccess_TrustZone_NS.ewp, settings and files
configuration GTZC_MPCWM_IllegalAccess_TrustZone_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32H573II ST STM32H573II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H573xx
  ICCARM.CCIncludePath2: ../../NonSecure/Inc; ../../Secure_nsclib; ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H5xx_HAL_Driver//Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GTZC_MPCWM_IllegalAccess_TrustZone_NS.hex
  ILINK.IlinkOutputFile: GTZC_MPCWM_IllegalAccess_TrustZone_NS.out
  ILINK.IlinkIcfFile: stm32h573xx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h573xx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32h5xx_ns.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c
