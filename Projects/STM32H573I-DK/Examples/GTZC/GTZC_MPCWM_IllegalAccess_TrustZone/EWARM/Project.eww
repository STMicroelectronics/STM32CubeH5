<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NonSecure\GTZC_MPCWM_IllegalAccess_TrustZone_NS.ewp</path>
  </project><project>
    <path>$WS_DIR$\Secure\GTZC_MPCWM_IllegalAccess_TrustZone_S.ewp</path>
  </project>
  <batchBuild />
</workspace>
