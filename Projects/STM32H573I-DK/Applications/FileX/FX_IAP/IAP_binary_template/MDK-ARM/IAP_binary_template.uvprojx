# Keil uVision project IAP_binary_template.uvprojx, settings and files
target IAP_binary_template (6210000::V6.21::ARMCLANG)
  device: STM32H573IIKx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x30000000,0x040000) IROM(0x08000000,0x00200000) IROM2(0x0C000000,0x00200000) XRAM(0x20040000,0x00010000) XRAM2(0x20050000,0x00050000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: IAP_binary_template
  AfterMake: fromelf #L --bin --output=$LSTM32_FW_UPGRADE.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H573xx
  c include: ../Core/Inc;../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT6: RAM 0x20040000 size 0x10000
  memory RVCT7: RAM 0x20050000 size 0x50000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32h573xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Doc
    ../: README.md
software components: CMSIS:CORE 5.4.0
