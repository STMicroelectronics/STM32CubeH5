# Keil uVision project Tx_MPU.uvprojx, settings and files
target Tx_Module (6190000::V6.19::ARMCLANG)
  device: STM32H573IIKx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x30000000,0x040000) IROM(0x08000000,0x00200000) IROM2(0x0C000000,0x00200000) XRAM(0x20040000,0x00010000) XRAM2(0x20050000,0x00050000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Tx_Module +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H573xx,TX_SINGLE_MODE_NON_SECURE
  c include: ../../../../../../Middlewares/ST/threadx/common/inc/;../../../../../../Middlewares/ST/threadx/common_modules/inc/;../../../../../../Middlewares/ST/threadx/ports_module/cortex_m33/ac6/inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Inc
  asm define: TXM_MODULE_HEAP_SIZE=512,TXM_ASSEMBLY, TX_SINGLE_MODE_NON_SECURE
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT6: RAM 0x20040000 size 0x10000
  memory RVCT7: RAM 0x20050000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  link misc: --entry default_module_start --first __txm_module_preamble
  group Application/MDK-ARM
    ./: startup_stm32h573xx.s
  group Application/User/Tx_ModuleManager
    ../Src/: main.c app_threadx.c stm32H5xx_hal_msp.c stm32H5xx_hal_timebase_tim.c stm32H5xx_it.c tx_initialize_low_level.S
  group Middlewares/RTOS/ThreadX/Core
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c tx_thread_stack_error_handler.c
  group Middlewares/RTOS/ThreadX/Module_Manager
    ../../../../../../Middlewares/ST/threadx/common_modules/module_manager/src/: txm_module_manager_absolute_load.c txm_module_manager_application_request.c txm_module_manager_callback_request.c txm_module_manager_event_flags_notify_trampoline.c txm_module_manager_file_load.c txm_module_manager_in_place_load.c txm_module_manager_initialize.c txm_module_manager_internal_load.c txm_module_manager_maximum_module_priority_set.c txm_module_manager_memory_load.c txm_module_manager_object_allocate.c txm_module_manager_object_deallocate.c txm_module_manager_object_pointer_get.c txm_module_manager_object_pointer_get_extended.c txm_module_manager_object_pool_create.c txm_module_manager_properties_get.c txm_module_manager_queue_notify_trampoline.c txm_module_manager_semaphore_notify_trampoline.c txm_module_manager_start.c txm_module_manager_stop.c txm_module_manager_thread_create.c txm_module_manager_thread_notify_trampoline.c txm_module_manager_thread_reset.c txm_module_manager_timer_notify_trampoline.c txm_module_manager_unload.c txm_module_manager_util.c txm_module_manager_kernel_dispatch.c
    ../../../../../../Middlewares/ST/threadx/ports_module/cortex_m33/ac6/module_manager/src/: tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S txm_module_manager_alignment_adjust.c txm_module_manager_external_memory_enable.c txm_module_manager_memory_fault_handler.c txm_module_manager_memory_fault_notify.c txm_module_manager_mm_register_setup.c txm_module_manager_thread_stack_build.S tx_thread_context_restore.S txe_thread_secure_stack_allocate.c txe_thread_secure_stack_free.c txm_module_manager_port_dispatch.c
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_thread_stack_error_notify.c
  group Middlewares/RTOS/ThreadX/PerformanceInfo
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c
  group Middlewares/RTOS/ThreadX/TraceX
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32H5xx_hal.c stm32H5xx_hal_cortex.c stm32H5xx_hal_dma.c stm32H5xx_hal_dma_ex.c stm32H5xx_hal_exti.c stm32H5xx_hal_flash.c stm32H5xx_hal_flash_ex.c stm32H5xx_hal_gpio.c stm32H5xx_hal_i2c.c stm32H5xx_hal_i2c_ex.c stm32H5xx_hal_pwr.c stm32H5xx_hal_pwr_ex.c stm32H5xx_hal_rcc.c stm32H5xx_hal_rcc_ex.c stm32H5xx_hal_tim.c stm32H5xx_hal_tim_ex.c stm32H5xx_hal_uart.c stm32H5xx_hal_uart_ex.c stm32H5xx_hal_usart.c stm32H5xx_hal_icache.c
  group Drivers/CMSIS
    ../Src/: system_stm32H5xx.c
  group Application/User/Tx_Module
    ../Src/: app_module.c
    ./: txm_module_preamble.S retarget.c Serial.c
  group Middlewares/RTOS/ThreadX/Module_Lib
    ../../../../../../Middlewares/ST/threadx/common_modules/module_lib/src/: txm_block_allocate.c txm_block_pool_create.c txm_block_pool_delete.c txm_block_pool_info_get.c txm_block_pool_performance_info_get.c txm_block_pool_performance_system_info_get.c txm_block_pool_prioritize.c txm_block_release.c txm_byte_allocate.c txm_byte_pool_create.c txm_byte_pool_delete.c txm_byte_pool_info_get.c txm_byte_pool_performance_info_get.c txm_byte_pool_performance_system_info_get.c txm_byte_pool_prioritize.c txm_byte_release.c txm_event_flags_create.c txm_event_flags_delete.c txm_event_flags_get.c txm_event_flags_info_get.c txm_event_flags_performance_info_get.c txm_event_flags_performance_system_info_get.c txm_event_flags_set.c txm_event_flags_set_notify.c txm_module_application_request.c txm_module_callback_request_thread_entry.c txm_module_object_allocate.c txm_module_object_deallocate.c txm_module_object_pointer_get.c txm_module_object_pointer_get_extended.c txm_module_thread_system_suspend.c txm_mutex_create.c txm_mutex_delete.c txm_mutex_get.c txm_mutex_info_get.c txm_mutex_performance_info_get.c txm_mutex_performance_system_info_get.c txm_mutex_prioritize.c txm_mutex_put.c txm_queue_create.c txm_queue_delete.c txm_queue_flush.c txm_queue_front_send.c txm_queue_info_get.c txm_queue_performance_info_get.c txm_queue_performance_system_info_get.c txm_queue_prioritize.c txm_queue_receive.c txm_queue_send.c txm_queue_send_notify.c txm_semaphore_ceiling_put.c txm_semaphore_create.c txm_semaphore_delete.c txm_semaphore_get.c txm_semaphore_info_get.c txm_semaphore_performance_info_get.c txm_semaphore_performance_system_info_get.c txm_semaphore_prioritize.c txm_semaphore_put.c txm_semaphore_put_notify.c txm_thread_create.c txm_thread_delete.c txm_thread_entry_exit_notify.c txm_thread_identify.c txm_thread_info_get.c txm_thread_interrupt_control.c txm_thread_performance_info_get.c txm_thread_performance_system_info_get.c txm_thread_preemption_change.c txm_thread_priority_change.c txm_thread_relinquish.c txm_trace_buffer_full_notify.c txm_thread_reset.c txm_thread_resume.c txm_thread_sleep.c txm_thread_stack_error_notify.c txm_thread_suspend.c txm_thread_terminate.c txm_thread_time_slice_change.c txm_thread_wait_abort.c txm_time_get.c txm_time_set.c txm_timer_activate.c txm_timer_change.c txm_timer_create.c txm_timer_deactivate.c txm_timer_delete.c txm_timer_info_get.c txm_timer_performance_info_get.c txm_timer_performance_system_info_get.c txm_trace_disable.c txm_trace_enable.c txm_trace_event_filter.c txm_trace_event_unfilter.c txm_trace_interrupt_control.c txm_trace_isr_enter_insert.c txm_trace_isr_exit_insert.c txm_trace_user_event_insert.c
    ../../../../../../Middlewares/ST/threadx/ports_module/cortex_m33/ac6/module_lib/src/: txm_module_initialize.S txm_module_thread_shell_entry.c
  group Doc
    ../: README.md
target Tx_ModuleManager (6190000::V6.19::ARMCLANG)
  device: STM32H573IIKx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.5.0-A02
  cpu: as above
  output: Tx_ModuleManager +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H573xx,TX_SINGLE_MODE_NON_SECURE,TXM_MODULE_INCLUDE_USER_DEFINE_FILE
  c include: ../Inc;../Common/Inc;../../../../../../Middlewares/ST/threadx/common/inc/;../../../../../../Middlewares/ST/threadx/common_modules/inc/;../../../../../../Middlewares/ST/threadx/common_modules/module_manager/inc/;../../../../../../Middlewares/ST/threadx/ports_module/cortex_m33/ac6/inc/;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32H573I-DK;..\MDK-ARM
  asm define: TX_SINGLE_MODE_NON_SECURE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT6: RAM 0x20040000 size 0x10000
  memory RVCT7: RAM 0x20050000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x30000
