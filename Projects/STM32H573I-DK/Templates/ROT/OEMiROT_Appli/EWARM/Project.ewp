# IAR project Project.ewp, settings and files
configuration Templates_OEMiROT_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H573II ST STM32H573II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32H573xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include; ..\..\..\..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H573I-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\Binary\rot_tz_s_app.bin
  postbuild: postbuild.bat "secure"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h573xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H573I-DK
    ../../../../../../Drivers/BSP/STM32H573I-DK/: stm32h573i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32h573xx.s
  group Example/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
