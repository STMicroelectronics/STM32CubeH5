# Keil uVision project Project.uvprojx, settings and files
target Templates_OEMiROT_Appli (6190000::V6.19::ARMCLANG)
  device: STM32H573IIKx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.4.0-RC1
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L"\..\..\..\Binary\rot_tz_s_app.bin"
  AfterMake: .\postbuild.bat "secure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H573xx,USE_HAL_DRIVER
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H573I-DK;../Inc
  library: MicroLIB
  scatter file: stm32h573xx.sct
  group Doc
    ../: README.md
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32H573I-DK/: stm32h573i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32h573xx.s
  group Application/User
    ../Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
software components: CMSIS:CORE 4.3.0
